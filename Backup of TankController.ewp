# IAR project Backup of TankController.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../Libraries/CMSIS/Device/ST/STM32F4xx/Include; ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates; ../Libraries/STM32F4xx_StdPeriph_Driver/inc; RCC; ADC; DAC; UserLibrary; Definitions; VTimers; USART; Serial; MyTimers; RS232; ModBusSlave; Controller; Display
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TankController.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c stm32f4xx_conf.h
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group ADC
    ADC/: adc.c adc.h
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
  group DAC
    DAC/: dac.c dac.h
  group Definitions
    Definitions/: definitions.h initPeripheral.c initPeripheral.h
  group Display
    Display/: LCD.c LCD.h
  group ModBusMaster
    ModBusMaster/: mbmaster.c mbmaster.h
  group ModBusSlave
    ModBusSlave/: mbcrc.c mbcrc.h mbslave.c mbslave.h
  group MyTimers
    MyTimers/: mytim.c mytim.h
  group RCC
    RCC/: rcc.c rcc.h
  group RS232
    RS232/: rs232.c rs232.h
  group Serial
    Serial/: serial.c serial.h
  group STDPeriph
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_dac.h stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h
  group TankController
    Controller/: tankController.c tankController.h
  group USART
    USART/: usart.c usart.h
  group UserLibrary
    UserLibrary/: userLibrary.c userLibrary.h
  group VTimers
    VTimers/: VTimer.c VTimer.h
